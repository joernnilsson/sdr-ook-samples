<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filename</value></param>
<param><key>value</key><value>"/tmp/wave-1.wav"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>433.92e6</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>record</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>0.05</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>0.03</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>file</key><value>filename if record else "/dev/null"</value></param>
<param><key>samp_rate</key><value>int(samp_rate)</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
import time
from gnuradio import gr

class blk(gr.sync_block):
    def __init__(self, sample_rate=2e6, packet_spacing=0.002):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='OOK us pulse sink',
            in_sig=[np.float32],
            out_sig=[]
        )
        self.sample_rate = sample_rate
        self.packet_spacing = packet_spacing * self.sample_rate

        self.packet_samples = 0
        self.packet = []


    def dump_packet (self):
        us_per_sample = 1000000 / self.sample_rate
        print(str (time.time ()) + " us edges: \t" + ", ".join (str( int(x * us_per_sample) ) for x in self.packet))
        self.packet = []
        self.packet_samples = 0

    def work (self, input_items, *args, **kwargs):

        samples = input_items [0]
        diff = np.diff (samples)

        # Get the indices of rising and falling edges        
        edges = np.nonzero(diff)[0]

        # TODO Detect packet end within edges

        if len(self.packet) == 0:
            if len(edges) &gt; 0:
                self.packet = [x - edges[0] for x in edges]
                self.packet_samples = len(samples) - edges[0]

        else:
            self.packet += [x + self.packet_samples for x in edges]
            self.packet_samples += len(samples)

            if (self.packet_samples - self.packet[-1]) &gt; self.packet_spacing:
                self.dump_packet()

        return len (samples)
</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>packet_spacing</key><value>0.002</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
import time
from gnuradio import gr


class blk(gr.sync_block):
    def __init__(self, sample_rate=2e6, max_group_spacing=0.0025, max_pulse_spacing=0.00065):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='OOK pulse group',
            in_sig=[np.float32],
            out_sig=[]
        )
        self.sample_rate = sample_rate

        self.max_group_spacing = max_group_spacing * self.sample_rate
        self.max_pulse_spacing = max_pulse_spacing * self.sample_rate

        self.packet_samples = 0
        self.packet = []


    def dump_packet (self):

        groups = []
        g = 1
        for i in range(1, len(self.packet)):
            diff_to_prev = self.packet[i] - self.packet[i-1]
            if diff_to_prev &gt; self.max_pulse_spacing:
                
                # add previous group
                groups.append(g)
                g = 0

                # add zero-groups, if any
                groups += [0 for x in range(int(diff_to_prev / self.max_group_spacing))]

            g += 1
        groups.append(g)
            
        print(str (time.time ()) + " groups: \t" + ", ".join (str(x) for x in groups))
        self.packet = []
        self.packet_samples = 0

    def work (self, input_items, *args, **kwargs):

        samples = input_items [0]
        diff = np.diff (samples)

        # Get the indices of rising and falling edges        
        #edges = np.nonzero(diff)[0]
        edges = np.where(diff == 1)[0]

        # TODO Detect packet end within edges

        if len(self.packet) == 0:
            if len(edges) &gt; 0:
                self.packet = [x - edges[0] for x in edges]
                self.packet_samples = len(samples) - edges[0]

        else:
            self.packet += [x + self.packet_samples for x in edges]
            self.packet_samples += len(samples)

            if (self.packet_samples - self.packet[-1]) &gt; self.max_group_spacing*3:
                self.dump_packet()



        return len (samples)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max_group_spacing</key><value>0.0018</value></param>
<param><key>max_pulse_spacing</key><value>0.00065</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>epy_block_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>epy_block_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
